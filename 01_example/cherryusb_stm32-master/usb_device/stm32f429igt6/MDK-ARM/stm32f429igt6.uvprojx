# Keil uVision project stm32f429igt6.uvprojx, settings and files
target stm32f429igt6 (6140001::V6.14.1::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: stm32f429igt6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\CherryUSB\core;..\..\..\CherryUSB\common;..\..\..\CherryUSB\class\cdc;..\..\..\CherryUSB\class\msc;..\..\..\CherryUSB\class\hid;..\..\..\CherryUSB\class\audio;..\..\..\CherryUSB\class\video;..\..\..\CherryUSB\class\hub;..\..\..\CherryUSB\third_party\FreeRTOS-10.4\include;..\..\..\CherryUSB\third_party\FreeRTOS-10.4\portable\GCC\ARM_CM4F;..\..\..\CherryUSB\osal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../../../CherryUSB/demo/: cdc_acm_msc_template.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CherryUSB
    ../../../CherryUSB/class/msc/: usbd_msc.c
    ../../../CherryUSB/class/hid/: usbd_hid.c
    ../../../CherryUSB/core/: usbd_core.c
    ../../../CherryUSB/port/dwc2/: usb_dc_dwc2.c usb_glue_st.c
    ../../../CherryUSB/osal/: usb_osal_freertos.c
    ../../../CherryUSB/class/cdc/: usbd_cdc_acm.c
  group FreeRTOS
    ../../../CherryUSB/third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../CherryUSB/third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../../CherryUSB/third_party/FreeRTOS-10.4/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.4.0
